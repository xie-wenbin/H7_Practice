# Keil uVision project base.uvprojx, settings and files
target H747_DISCO_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: base +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx, USE_STM32H747I_DISCO,CORE_CM7
  c include: ..\..\Common\Inc;..\..\CM7\Include;..\..\CM7;..\..\CM7\Source;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\Bsp\User;..\..\Bsp\STM32H747I-DISCO;..\..\Bsp\Components\is42s32800j;..\..\Bsp\Components\otm8009a;..\..\Bsp\User\Fonts;..\..\Bsp\User\lcd;..\..\Bsp\Components\Common;..\..\Bsp\Components\ft6x06
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  group User/CM7
    ../../CM7/: stm32h7xx_hal_conf.h main.c stm32h7xx_hal_msp.c stm32h7xx_it.c Appl_sdram_test.c test_image.c
  group User/CM4
    ../../CM4/: stm32h7xx_hal_conf.h main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Startup
    ../../Common/startup/: startup_stm32h747xx.s
  group BSP/CM7
    ../../CM7/Source/: bsp.c bsp_key.c bsp_led.c bsp_timer.c bsp_uart.c bsp_tim_pwm.c bsp_fmc_sdram.c bsp_dwt.c bsp_lcd_svc.c bsp_lcd_utils.c bsp_lcd_hw.c bsp_lcd.c bsp_i2c.c bsp_lcd_ts.c
    ../../CM7/: Appl_lcd_test.c
  group Drivers
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_ll_bdma.c stm32h7xx_hal_dsi.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c
  group CMSIS
    ../../Common/Src/: system_stm32h7xx.c
  group BSP/Components
    ../../Bsp/Components/is42s32800j/: is42s32800j.c
    ../../Bsp/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../../Bsp/Components/ft6x06/: ft6x06.c ft6x06_reg.c
target H747_DISCO_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: base_cm4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx,USE_STM32H747I_DISCO,CORE_CM4
  c include: ..\..\Common\Inc;..\..\CM4\Include;..\..\CM4;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\Bsp\STM32H747I-DISCO;..\..\Bsp\User
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
software components: Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
