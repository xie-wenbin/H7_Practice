# Keil uVision project base.uvprojx, settings and files
target H747_DISCO_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: base +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx, USE_STM32H747I_DISCO,CORE_CM7
  c include: ..\..\Common\Inc;..\..\CM7;..\..\CM7\bsp;..\..\CM7\app;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\Drivers\BSP\Components\ft6x06;..\..\Drivers\BSP\Components\is42s32800j;..\..\Drivers\BSP\Components\otm8009a;..\..\Drivers\BSP\Components\mt25tl01g;..\..\Drivers\BSP\Fonts;..\..\Middlewares\Third_Party\FreeRTOS\include;..\..\Middlewares\Third_Party\FreeRTOS\CMSIS_RTOS_V2;..\..\Middlewares\Third_Party\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\Middlewares\Third_Party\FatFs\src;..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\CM7\application_test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\base.sct
  group Startup
    ../../Common/startup/: startup_stm32h747xx.s
  group CM7/Core
    ../../CM7/: FreeRTOSConfig.h stm32h7xx_hal_conf.h main.c stm32h7xx_hal_msp.c stm32h7xx_it.c stm32h7xx_hal_timebase_tim.c bsp.c
  group CM4/Core
    ../../CM4/: stm32h7xx_hal_conf.h main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group CM7/APP
    ../../CM7/application_test/: Appl_sdram_test.c test_image.c
    ../../CM7/app/: appGUI.c appPicBinary.c appQspi.c appSd.c
  group CM7/BSP
    ../../CM7/bsp/: bsp_dwt.c bsp_fmc_sdram.c bsp_i2c.c bsp_key.c bsp_lcd.c bsp_lcd_hw.c bsp_lcd_svc.c bsp_lcd_ts.c bsp_lcd_utils.c bsp_led.c bsp_tim_pwm.c bsp_timer.c bsp_uart.c bsp_qspi_flash.c bsp_sdio_sd.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
  group Drivers/CMSIS
    ../../Common/Src/: system_stm32h7xx.c
  group Drivers/HAL_Drivers
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_ll_bdma.c stm32h7xx_hal_dsi.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../Middlewares/Third_Party/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../Middlewares/Third_Party/FreeRTOS/portable/MemMang/: heap_4.c
  group Middlewares/FatFS
    ../../Middlewares/Third_Party/FatFs/src/: ff.c ffconf.h ff_gen_drv.c diskio.c
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio_dma.c
target H747_DISCO_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: base_cm4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H747xx,USE_STM32H747I_DISCO,CORE_CM4
  c include: ..\..\Common\Inc;..\..\CM4\Include;..\..\CM4;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\Bsp\STM32H747I-DISCO;..\..\Bsp\User
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
software components: Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
